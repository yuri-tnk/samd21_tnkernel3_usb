# IAR project rtos_usb_g.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21G18A Microchip ATSAMD21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __SAMD21G18A__; DONT_USE_CMSIS_INIT; F_CPU=48000000
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; os; usb_asf4; usb_asf4\device; usb_asf4\hal\include; usb_asf4\hal\utils\include; usb_asf4\hri; usb_asf4\class\cdc; usb_asf4\class\cdc\device; usb_asf4\hpl\pm; usb_asf4\hpl\gclk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: rtos_usb_g.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bsp_dma.c bsp_hw.c bsp_uart0.c bsp_usb_uart.c bsp_usb_uart.h hal_gpio.h main.c prj_conf.h prj_def.h prj_shell_func.c shell.c shell.h startup_samd21.c tn_config.h tn_sprintf.c tn_user.c
  group os
    os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
  group os/CortexM0_M7
    os/CortexM0_M7/: tn_port_CortexM0_M7.c tn_port_CortexM0_M7_asm.S
  group usb_asf4
    usb_asf4/: usb_atmel.h usb_debug.h usb_includes.h usb_protocol.c usb_protocol.h
  group usb_asf4/class/cdc
    usb_asf4/class/cdc/: usb_protocol_cdc.h
  group usb_asf4/class/cdc/device
    usb_asf4/class/cdc/device/: cdcdf_acm.c cdcdf_acm.h cdcdf_acm_desc.h
  group usb_asf4/device
    usb_asf4/device/: usbdc.c usbdc.h
  group usb_asf4/hal/include
    usb_asf4/hal/include/: hal_adc_sync.h hal_atomic.h hal_dac_sync.h hal_delay.h hal_flash.h hal_gpio.h hal_i2c_m_sync.h hal_init.h hal_io.h hal_pwm.h hal_sleep.h hal_spi_m_dma.h hal_spi_m_sync.h hal_timer.h hal_usart_async.h hal_usb_device.h hpl_adc_async.h hpl_adc_dma.h hpl_adc_sync.h hpl_calendar.h hpl_core.h hpl_dac_async.h hpl_dac_sync.h hpl_delay.h hpl_dma.h hpl_flash.h hpl_gpio.h hpl_i2c_m_async.h hpl_i2c_m_sync.h hpl_i2c_s_async.h hpl_i2c_s_sync.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_pwm.h hpl_reset.h hpl_sleep.h hpl_spi.h hpl_spi_async.h hpl_spi_dma.h hpl_spi_m_async.h hpl_spi_m_dma.h hpl_spi_m_sync.h hpl_spi_s_async.h hpl_spi_s_sync.h hpl_spi_sync.h hpl_time_measure.h hpl_timer.h hpl_usart.h hpl_usart_async.h hpl_usart_sync.h hpl_usb.h hpl_usb_device.h hpl_usb_host.h hpl_user_area.h
  group usb_asf4/hal/src
    usb_asf4/hal/src/: hal_atomic.c hal_usb_device.c
  group usb_asf4/hal/utils/include
    usb_asf4/hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_decrement_macro.h utils_event.h utils_increment_macro.h utils_list.h utils_recursion_macro.h utils_repeat_macro.h utils_ringbuffer.h
  group usb_asf4/hal/utils/src
    usb_asf4/hal/utils/src/: utils_assert.c utils_event.c utils_list.c utils_ringbuffer.c
  group usb_asf4/hpl/usb
    usb_asf4/hpl/usb/: hpl_usb.c
  group usb_asf4/hri
    usb_asf4/hri/: hri_ac_d21.h hri_adc_d21.h hri_d21.h hri_dac_d21.h hri_dmac_d21.h hri_dsu_d21.h hri_eic_d21.h hri_evsys_d21.h hri_gclk_d21.h hri_hmatrixb_d21.h hri_i2s_d21.h hri_mtb_d21.h hri_nvic_d21.h hri_nvmctrl_d21.h hri_pac_d21.h hri_pm_d21.h hri_port_d21.h hri_rtc_d21.h hri_sercom_d21.h hri_sysctrl_d21.h hri_systemcontrol_d21.h hri_systick_d21.h hri_tc_d21.h hri_tcc_d21.h hri_usb_d21.h hri_wdt_d21.h
